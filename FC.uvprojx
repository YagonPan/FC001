# Keil uVision project FC.uvprojx, settings and files
target FC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Low;.\Middle;.\Library\inc;.\Sys_Core;.\Top;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c define.c init.c
  group Middle
    ./Middle/: printf.c oled.c oled.h mpu6050.c mpu6050.h
  group Low
    ./Low/: gpio_def.c usart1.c delay.c i2c1.c i2c1.h i2c2.c i2c2.h
  group Library
    ./Library/src/: misc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_it.c
  group Sys_Core
    ./Sys_Core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
software components: CMSIS:CORE 5.2.0
